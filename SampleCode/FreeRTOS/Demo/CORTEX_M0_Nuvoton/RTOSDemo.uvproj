# Keil uVision project RTOSDemo.uvproj, settings and files
target XMC1300 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: XMC1302-200 Infineon
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x10001000-0x10032FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: RTOSDemo
  c flags: Optim=1
  c include: ..\CORTEX_M0_Infineon_XMC1000_IAR_Keil_GCC;..\..\Source\include;..\..\Source\portable\RVDS\ARM_CM0;..\Common\include;.\CMSIS;.\Keil_Specific;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC100Series\Include;..\..\..\..\Library\StdDriver\inc
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group System
    ../../../../Library/Device/Nuvoton/NUC100Series/Source/: system_NUC100Series.c
    ../../../../Library/Device/Nuvoton/NUC100Series/Source/ARM/: startup_NUC100Series.s
  group FreeRTOS source
    ../../Source/: timers.c list.c queue.c tasks.c
    ../../Source/portable/RVDS/ARM_CM0/: port.c
    ../../Source/portable/MemMang/: heap_4.c
  group Demo App Source
    ./: main.c main-blinky.c FreeRTOSConfig.h main-full.c ParTest_XMC1300.c
    ./Keil_Specific/: RegTest_Keil.s
    ../../../../Library/StdDriver/src/: retarget.c
  group Common Demo Tasks
    ../Common/Minimal/: dynamic.c recmutex.c blocktim.c countsem.c QueueSet.c QueueOverwrite.c

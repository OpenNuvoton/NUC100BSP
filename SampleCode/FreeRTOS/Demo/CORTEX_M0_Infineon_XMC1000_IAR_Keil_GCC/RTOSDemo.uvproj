# Keil uVision project RTOSDemo.uvproj, settings and files
target XMC1300 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: XMC1302-200 Infineon
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x10001000-0x10032FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: RTOSDemo
  c include: ..\CORTEX_M0_Infineon_XMC1000_IAR_Keil_GCC;..\..\Source\include;..\..\Source\portable\RVDS\ARM_CM0;..\Common\include;.\CMSIS;.\Keil_Specific
  memory RVCT4: ROM 0x10001000 size 0x32000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group System
    ./Keil_Specific/: startup_XMC1000.s system_XMC1300.c system_XMC1100.c system_XMC1200.c
  group FreeRTOS source
    ../../Source/: timers.c list.c queue.c tasks.c
    ../../Source/portable/RVDS/ARM_CM0/: port.c
    ../../Source/portable/MemMang/: heap_4.c
  group Demo App Source
    ./: main.c main-blinky.c FreeRTOSConfig.h main-full.c ParTest_XMC1200.c ParTest_XMC1100.c ParTest_XMC1300.c
    ./Keil_Specific/: RegTest_Keil.s
  group Common Demo Tasks
    ../Common/Minimal/: dynamic.c recmutex.c blocktim.c countsem.c QueueSet.c QueueOverwrite.c
target XMC1200 (5060020::V5.06 (build 20)::ARMCC)
  device: XMC1200-200 Infineon
  cpu: as above
  output: RTOSDemo
  c flags: Optim=1
  c include: .;..\Common\include;..\..\Source\include;..\..\Source\portable\RVDS\ARM_CM0;.\CMSIS;.\Keil_Specific
  library: MicroLIB
  memory RVCT4: ROM 0x10001000 size 0x32000
  memory RVCT9: RAM 0x20000000 size 0x4000
target XMC1100 (5060020::V5.06 (build 20)::ARMCC)
  device: XMC1100-64 Infineon
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x10001000-0x10010FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: RTOSDemo
  c flags: Optim=1
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x10001000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
